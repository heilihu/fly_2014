# Keil uVision project AnBT_Main_FWH.uvproj, settings and files
target BS004X_Fly_With_BL (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AnBT_Main_FWH +hex
  AfterMake: fromelf.exe --bin -o ..\release\bs4x2014_bt_fly_t1.bin ..\output\anbt_main_fwh.axf
  c flags: Optim=1
  c include: ..\stm32_lib\inc;..\etootle_lib;..\etootle_user
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group etootle_user
    ../etootle_user/: etootle_main.c
  group etootle_lib
    ../etootle_lib/: etootle_adc.c etootle_bluetooth.c etootle_imu.c etootle_led.c etootle_motor.c etootle_mpu6050.c etootle_parameter.c etootle_pid.c etootle_sys.c
  group stm32_lib
    ../stm32_lib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../stm32_lib/startup/: cortexm3_macro.s stm32f10x_vector.s
  group license
    ../Readme/: readme.c
